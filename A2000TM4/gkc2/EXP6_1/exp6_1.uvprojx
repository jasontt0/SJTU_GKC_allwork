# Keil uVision project exp6_1.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: exp6_1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C1294NCPDT
  c include: F:\Software_downloads\for_Keil_5\TivaWare_C_Series-2.1.4.178; ./; ../
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: ADC.c ADC.h exp6_1.c LM75BD.c LM75BD.h PWM.c PWM.h tm1638.c tm1638.h
  group New Group
    F:/Software_downloads/for_Keil_5/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
software components: Device:Startup 1.0.0
